options:
  parameters:
    generate_options: qt_gui
    id: multi_ue_scenario
    output_language: python
    title: srsRAN_multi_UE
  states: {}

blocks:
- name: noise_amplitude1
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0.001'
    option1: '0.03'
    option2: '0.05'
    type: real
    value: '0.001'
  states: {}
- name: noise_amplitude2
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0.001'
    option1: '0.03'
    option2: '0.05'
    type: real
    value: '0.001'
  states: {}
- name: noise_amplitude3
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0.001'
    option1: '0.03'
    option2: '0.05'
    type: real
    value: '0.001'
  states: {}
- name: noise_amplitude4
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0.001'
    option1: '0.03'
    option2: '0.05'
    type: real
    value: '0.001'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '11520000'
  states: {}
- name: slow_down_ratio
  id: variable_qtgui_range
  parameters:
    label: Time Slow Down Ratio
    start: '1'
    step: '1'
    stop: '32'
    value: '1'
  states: {}
- name: vehicular_speed1
  id: variable_qtgui_chooser
  parameters:
    num_opts: '4'
    option0: '10'
    option1: '30'
    option2: '60'
    option3: '70'
    type: int
    value: '60'
  states: {}
- name: vehicular_speed2
  id: variable_qtgui_chooser
  parameters:
    num_opts: '4'
    option0: '10'
    option1: '30'
    option2: '60'
    option3: '70'
    type: int
    value: '60'
  states: {}
- name: vehicular_speed3
  id: variable_qtgui_chooser
  parameters:
    num_opts: '4'
    option0: '10'
    option1: '30'
    option2: '60'
    option3: '70'
    type: int
    value: '60'
  states: {}
- name: vehicular_speed4
  id: variable_qtgui_chooser
  parameters:
    num_opts: '4'
    option0: '10'
    option1: '30'
    option2: '60'
    option3: '70'
    type: int
    value: '60'
  states: {}
- name: zmq_hwm
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: zmq_timeout
  id: variable
  parameters:
    value: '500'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_dynamic_channel_model_0
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0,0.00000031,0.00000071,0.00000109,0.00000173,0.00000251]'
    fD: (vehicular_speed3/3.6)*(36.85/3)
    mags: '[0,-1,-9,-10,-15,-20]'
    noise_amp: noise_amplitude3
    ntaps: '6'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: channels_dynamic_channel_model_0_0
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0,0.00000031,0.00000071,0.00000109,0.00000173,0.00000251]'
    fD: (vehicular_speed4/3.6)*(36.85/3)
    mags: '[0,-1,-9,-10,-15,-20]'
    noise_amp: noise_amplitude4
    ntaps: '6'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: channels_dynamic_channel_model_1
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0,0.00000031,0.00000071,0.00000109,0.00000173,0.00000251]'
    fD: (vehicular_speed1/3.6)*(36.85/3)
    mags: '[0,-1,-9,-10,-15,-20]'
    noise_amp: noise_amplitude1
    ntaps: '6'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: channels_dynamic_channel_model_2
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    delays: '[0,0.00000031,0.00000071,0.00000109,0.00000173,0.00000251]'
    fD: (vehicular_speed2/3.6)*(36.85/3)
    mags: '[0,-1,-9,-10,-15,-20]'
    noise_amp: noise_amplitude2
    ntaps: '6'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2100
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2200
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2001
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_1_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:3001
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:3000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2101
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2201
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', channels_dynamic_channel_model_0, '0']
- [blocks_throttle_0_0, '0', channels_dynamic_channel_model_1, '0']
- [blocks_throttle_0_0_0, '0', channels_dynamic_channel_model_2, '0']
- [blocks_throttle_0_1, '0', channels_dynamic_channel_model_0_0, '0']
- [channels_dynamic_channel_model_0, '0', zeromq_rep_sink_0_1, '0']
- [channels_dynamic_channel_model_0_0, '0', zeromq_rep_sink_0_1_0, '0']
- [channels_dynamic_channel_model_1, '0', zeromq_rep_sink_0, '0']
- [channels_dynamic_channel_model_2, '0', zeromq_rep_sink_0_0, '0']
- [zeromq_req_source_0, '0', blocks_throttle_0_0, '0']
- [zeromq_req_source_0_0, '0', blocks_throttle_0_0_0, '0']
- [zeromq_req_source_1, '0', blocks_throttle_0, '0']
- [zeromq_req_source_1_0, '0', blocks_throttle_0_1, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-1-gee27d6f3
